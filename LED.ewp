# IAR project LED.ewp, settings and files
configuration EMB_FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EMB_FLASH
  ICCARM.CCIncludePath2: ; board\; Library\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LED.hex
  ILINK.IlinkOutputFile: LED.out
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: lib_sensor.c lib_sensor.h main.c
  group config
    ./: stm32f10x_conf.h System_func.c
  group cortex-m3
    board/: cortexm3_macro.s
  group Library
    ../../../ARM-Cortex-M3_Exam11/12.ADC/Library/src/: stm32f10x_adc.c
    Library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
    Library/inc/: stm32f10x_tim.h stm32f10x_usart.h
  group Vector
    ./: stm32f10x_it.c stm32f10x_it.h stm32f10x_vector.c
